# Keil uVision project Project.uvprojx, settings and files
target STM32L476RG_NUCLEO (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32L476ZGTx STMicroelectronics
  pack: Keil.STM32L4xx_DFP.2.0.0
  cpu: IRAM(0x20000000,0x00018000) IRAM2(0x10000000,0x00008000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: STM32L476RG_NUCLEO
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: STM32L476xx,USE_HAL_DRIVER,USE_STM32L4XX_NUCLEO
  c misc: --C99
  c include: ..\Inc;..\..\..\..\..\..\Drivers\CMSIS\Device\ST\STM32L4xx\Include;..\..\..\..\..\..\Drivers\STM32L4xx_HAL_Driver\Inc;..\..\..\..\..\..\Drivers\BSP\STM32L4xx_Nucleo;..\..\..\..\..\..\Drivers\BSP\Components\Common;..\..\..\..\..\..\Drivers\CMSIS\Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x18000
  memory RVCT10: RAM 0x10000000 size 0x8000
  link misc: --diag_suppress=L6329
  group Drivers/CMSIS
    ../Src/: system_stm32l4xx.c
  group Doc
    ../: readme.txt
  group Drivers/BSP/STM32L4xx_Nucleo
    ../../../../../../Drivers/BSP/STM32L4xx_Nucleo/: stm32l4xx_nucleo.c
  group Example/User
    ../Src/: main.c stm32l4xx_hal_msp.c stm32l4xx_it.c adpd.c
  group Drivers/STM32L4xx_HAL_Driver
    ../../../../../../Drivers/STM32L4xx_HAL_Driver/Src/: stm32l4xx_hal_uart_ex.c stm32l4xx_hal_gpio.c stm32l4xx_hal.c stm32l4xx_hal_i2c.c stm32l4xx_hal_dma.c stm32l4xx_hal_cortex.c stm32l4xx_hal_pwr_ex.c stm32l4xx_hal_rcc_ex.c stm32l4xx_hal_pwr.c stm32l4xx_hal_rcc.c stm32l4xx_hal_uart.c stm32l4xx_hal_i2c_ex.c
  group Example/MDK-ARM
    ./: startup_stm32l476xx.s
